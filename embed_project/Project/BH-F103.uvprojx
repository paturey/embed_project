# Keil uVision project BH-F103.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BH-F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,OS_SUPPORT
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\Libraries\lcd;..\third_lib\STemWin\inc;..\third_lib\STemWin\Config;..\third_lib\freertos\include;..\third_lib\freertos\portable;..\Libraries\flash;..\Libraries\usart;..\Libraries\sram;..\third_lib\STemWin_Task;..\Libraries\pwm;..\Libraries\led;..\Libraries\FATFS;..\Libraries\sdio;..\Libraries\key;..\Libraries\MFRC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c Touch_Task.c WIDGET_ButtonSimple.c FatFs_test.c test.c
    ../third_lib/STemWin_Task/: MainTask.c
  group DOC
    ../Doc/: readme.txt
  group FreeRTOS
    ../third_lib/freertos/: event_groups.c heap_4.c list.c queue.c tasks.c timers.c
    ../third_lib/freertos/portable/: port.c
  group STemwin
    ../third_lib/STemWin/Config/: GUI_X_Touch_Analog.c GUIConf.c LCDConf_FlexColor_Template.c
    ../third_lib/STemWin/OS/: GUI_X_FreeRTOS.c
    ../third_lib/STemWin/Lib/: STemWin_CM3_OS_wc16_ARGB.a
  group bsp
    ../Libraries/flash/: bsp_spi_flash.c
    ../Libraries/sram/: bsp_fsmc_sram.c
    ../Libraries/usart/: bsp_usart.c
    ../Libraries/lcd/: bsp_ili9341_lcd.c bsp_xpt2046_lcd.c
    ../Libraries/pwm/: PWM.c
    ../Libraries/led/: bsp_led.c
    ../Libraries/sdio/: bsp_sdio_sdcard.c
    ../Libraries/key/: bsp_key.c
    ../Libraries/MFRC/: bsp_MFRC.c
  group FatFs
    ../Libraries/FATFS/: diskio.c ff.c
    ../Libraries/FATFS/option/: cc936.c
